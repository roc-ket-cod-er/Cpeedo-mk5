# IAR project SPEEDO_1.ewp, settings and files
configuration SPEEDO_1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575VG ST STM32U575VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPEEDO_1.hex
  ILINK.IlinkOutputFile: SPEEDO_1.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_sdio.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_hcd.c stm32u5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
